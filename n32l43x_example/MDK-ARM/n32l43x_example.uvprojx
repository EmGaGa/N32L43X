# Keil uVision project n32l43x_example.uvprojx, settings and files
target N32L43x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L436RB Nationstech
  pack: Nationstech.N32L43x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Printf +hex
  AfterMake: fromelf --bin --output=.\bin\Printf.bin .\Objects\Printf.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L43X, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\inc;..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32l43x_std_periph_driver\inc;..\peripheral\key\inc;..\peripheral\usart\inc;..\peripheral\led\inc;..\peripheral\rcc\inc;..\peripheral\lcd;..\peripheral\spi_flash\inc;..\..\rt-thread\bsp;..\..\rt-thread\include;..\..\rt-thread\include\libc;..\..\rt-thread\components\finsh;..\..\ff14b\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32l43x.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32l43x.c
  group FWLB
    ../../firmware/n32l43x_std_periph_driver/src/: misc.c n32l43x_gpio.c n32l43x_usart.c n32l43x_rcc.c n32l43x_flash.c n32l43x_spi.c
  group USER
    ../src/: main.c n32l43x_it.c multi_button.c
    ../../rt-thread/bsp/: board.c rtconfig.h
  group DOC
    ../: readme.txt
  group peripheral
    ../peripheral/key/src/: key.c
    ../peripheral/usart/src/: usart.c
    ../peripheral/led/src/: led.c
    ../peripheral/rcc/src/: rcc.c
    ../peripheral/lcd/: lcd.c lcd_init.c
    ../peripheral/spi_flash/src/: bsp_spi_flash.c
  group rtt/port
    ../../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group rtt/source
    ../../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group finsh
    ../../rt-thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group ff14b
    ../../ff14b/source/: diskio.c ff.c ffsystem.c ffunicode.c
